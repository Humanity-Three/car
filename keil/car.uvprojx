# Keil uVision project car.uvprojx, settings and files
target Target 1 (6110000::V6.11::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: car
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3505__, __USE_SYSCONFIG__
  c include: ..\..\car;..\OLED;..\MPU6050;..\Grayscale_Sensor;..\Debug;D:\CCS\mspm0_sdk_2_10_00_04\source\ti\devices\msp\m0p;D:\CCS\mspm0_sdk_2_10_00_04\source\ti\devices\msp\m0p\driverlib\keil;D:\CCS\mspm0_sdk_2_10_00_04\source\ti\driverlib;D:\CCS\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;D:\CCS\mspm0_sdk_2_10_00_04\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: D:\CCS_workspace\car\Keil\mspm0g3507.sct
  link misc: "D:\CCS\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a"
  group Startup
    ./: startup_mspm0g350x_uvision.s
  group App
    ../: control.c empty.c
  group Hardware
    ../: Delay.c
    ../OLED/: OLED.c OLED_DATA.c
    ../MPU6050/: MPU6050.c
    ../Grayscale_Sensor/: grayscale_sensor.c
  group SysConfig
    ../Debug/: ti_msp_dl_config.c
